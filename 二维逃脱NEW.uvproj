# Keil uVision project 二维逃脱NEW.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C52X2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 二维逃脱NEW +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 movingnumberled.h main.c infrared.h gameoverbeep.h ds1302.h
